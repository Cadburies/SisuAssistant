# Repository Cadburies/SisuAssistant

File README.md:

# Sisu Marine Automation System

Marine automation for sailing vessel **Sisu**: dual alternators, tanks, freezer, helm instruments, Home Assistant, Signal K, and MQTT.

**Feature guide:** every screen, control and device, with how to reach it — [project wiki](https://github.com/Cadburies/SisuAssistant/wiki) (generated from [`.ai_context/feature_map/`](.ai_context/feature_map/)). Security reports: [`SECURITY.md`](SECURITY.md).

## Platform roles

| Function                                   | Hardware                                         |
| ------------------------------------------ | ------------------------------------------------ |
| Alternators Port / Starboard               | **Sisu Marine Board** (ESP32-S3-WROOM-2-N32R16V) |
| Tank / water levels                        | **Sisu Marine Board**                            |
| Freezer / fridge                           | **Marine Board** v1.9 controls (pending; manual until fitted; firmware is full speed or stop, #221); **LilyGo S3 AMOLED** displays over ESP-NOW |
| Home Assistant + MQTT kernel (`sisu/v1`)   | **HA Green** (Ethernet)                          |
| Signal K · Grafana / Influx · backups      | **TerraMaster F8** (Ethernet, Docker) |
| Chart / AIS / windex (Sisu Nav)            | Docker on F8 — `http://192.168.0.21:8088`, Follow me on `https://192.168.0.21:8443` (#188) |
| Helm engine / fuel gauges (planned)        | **Veratron OL43** (NMEA 2000, high-nits)         |

| Document                                  | Content                                                                                       |
| ----------------------------------------- | --------------------------------------------------------------------------------------------- |
| **[`INSTALLATION.md`](INSTALLATION.md)**  | **Wiring & commission manual** — Marine Board, alts, levels, freezer, Spectra, BMS, safety    |
| **[`OPS.md`](OPS.md)**                    | **Agent-first setup** — what only you do vs agent; SSH; ESPHome; Marine Board bench          |
| **[`NETWORK.md`](NETWORK.md)**            | Wi‑Fi 7 SSIDs, routing so **Sisu** can open HA and see IoT, F8 stack, secrets, helm, trending |
| **[`Technical Specifications.md`](Technical%20Specifications.md)** | System firmware roles & safety                                                      |
| **[`MarineBoard/`](MarineBoard/)** folder | KiCad hardware project (schematic, PCB, BOM) — **[`Technical Specs.md`](MarineBoard/Technical%20Specs.md)** is the PCB/GPIO/connector reference; **[`Documentation/`](MarineBoard/Documentation/)** has schematic-section PNG exports, order sheets, and the replacement plans (Spectra, Axiom, [Weekender freezer](MarineBoard/Documentation/Freezer-Replacement-Plan.md)); **[`enclosure/`](MarineBoard/enclosure/)** is the printed IP67-connector box (spec: *Enclosure* section); **[`daughter-fridge/`](MarineBoard/daughter-fridge/)** is the fridge daughter board project (schematic draft 0.1, not reviewed; [technical spec](MarineBoard/daughter-fridge/technical%20spec.md)) |
| **[`.ai_context/naming.md`](.ai_context/naming.md)** | Entity / Signal K / N2K names                                                     |
| **[`sisu-nav/`](sisu-nav/)** | Chart + AIS + windex + weather + isochrone routing — `http://192.168.0.21:8088`. Install: **[`sisu-nav/INSTALLATION.md`](sisu-nav/INSTALLATION.md)** · Usage: **[`sisu-nav/USER_GUIDE.md`](sisu-nav/USER_GUIDE.md)** · Dev: **[`sisu-nav/DEVELOPER.md`](sisu-nav/DEVELOPER.md)** · issues label **[sisu-nav](https://github.com/Cadburies/SisuAssistant/issues?q=label%3Asisu-nav)** |
| **[Wiki](https://github.com/Cadburies/SisuAssistant/wiki)** · [`.ai_context/feature_map/`](.ai_context/feature_map/) | **Feature guide** — one page per screen/control/device (how to reach it, what it does, what to expect); regenerated automatically from the feature map on every push. Format: [`DESIGN.md`](.ai_context/feature_map/DESIGN.md) |

## Network (summary)

**Router:** **GL.iNet GL-BE9300 (Flint 3)** Wi‑Fi 7

| SSID           | Subnet          | Clients                                      |
| -------------- | --------------- | -------------------------------------------- |
| **Sisu**       | 192.168.0.0/24  | Wi‑Fi 7 phones/laptops; HA Green; TNAS `.21` |
| **Sisu-IoT**   | 192.168.10.0/24 | All ESP32s (2.4 GHz)                         |
| **Sisu-Guest** | guest           | Isolated                                     |

| Host                               | IP                                  |
| ---------------------------------- | ----------------------------------- |
| HA Green                           | **192.168.0.20**                    |
| TNAS F8                            | **192.168.0.21**                    |
| Alt Port / Stbd / Levels / Freezer / Saloon display / Freezer display | **192.168.10.41 / .42 / .43 / .44 / .45 / .47** |

Phone stays on **Sisu** → `http://192.168.0.20:8123`; router **must** allow HA → `192.168.10.0/24`.

Full GL-BE9300 actions: **`NETWORK.md` §3–§4**. Agent ops: **`OPS.md`**.

## What runs where

```text
                 ┌──────────── Mac (source of truth: edit · commit · build · push) ────────────┐
                 │  ha-deploy-config.sh ─► HA Green      f8-deploy.sh ─► F8      esphome ─► ESPs │
                 └──────────────────────────────────────────────────────────────────────────────┘

 Sisu-IoT 192.168.10.x                     Sisu LAN 192.168.0.x
 ┌──────────────────────────┐  ESPHome   ┌───────────────────────────────┐ MQTT sisu/v1 ┌─────────────────────────┐
 │ Marine Boards .41–.44    │─── API ───►│ HA Green .20                  │─────────────►│ F8 .21 (Docker)         │
 │ Saloon display .45       │            │ HA Core · Mosquitto (kernel)  │ Influx write │ Signal K · InfluxDB     │
 │ YDWG .30 · DataHub .31   │─── NMEA ──►│ NMEA ingest · ESPHome builder │─────────────►│ Grafana · Sisu Nav · …  │
 │ Victron Color Control .32│─── MQTT ──►│ packages / python_scripts     │              └─────────────────────────┘
 └──────────────────────────┘            └───────────────────────────────┘
        N2K backbone: Raymarine instruments · engines · (Veratron OL43 planned) ─► YDWG / DataHub
```

Safety-relevant control (alternator field, hard cut-offs, freezer thermostat) runs **locally on each ESP32** — HA, MQTT and the F8 can all be down without losing it.

### Mac — source of truth and build machine

Every file HA Green and the F8 run from starts here (`AGENTS.md` rule 12): edit → commit → push. `./scripts/stack-drift.sh` shows any box that has drifted.

| What | How |
|---|---|
| Config + source for both boxes | this repo; push with `./scripts/ha-deploy-config.sh <files>` (HA Green) and `./scripts/f8-deploy.sh` (F8) |
| ESP32 firmware | `esphome config` / `compile` / first flash over USB-C; later OTA over Wi‑Fi |
| Marine Board hardware | KiCad project in [`MarineBoard/`](MarineBoard/); fab package via `MarineBoard/fab_package.py` |
| Markdown docs | VS Code + **Markdown All in One** (`yzhang.markdown-all-in-one`); `.vscode/` is per-machine and gitignored |
| Rollback only | `homeassistant/docker-compose.mac.yml` (the F8 stack, run locally) |

### HA Green — Home Assistant OS, `192.168.0.20`

| Runs | Does | Source |
|---|---|---|
| **Home Assistant Core** `:8123` | Dashboards, automations, all ESP32 devices (ESPHome API) | [`homeassistant/configuration.yaml`](homeassistant/configuration.yaml), [`dashboards/`](homeassistant/dashboards/), [`ui-lovelace.yaml`](homeassistant/ui-lovelace.yaml) |
| **Mosquitto** add-on `:1883` | The MQTT **kernel** (`sisu/v1`) everything else subscribes to | `core_mosquitto`; logins via `./scripts/ha-kernel-mqtt.sh` |
| **Sisu NMEA ingest** add-on | Reads YDWG (primary) + DataHub (fail-over) NMEA 0183 over TCP → MQTT | [`addons/sisu_nmea_ingest/`](homeassistant/addons/sisu_nmea_ingest/), [`nmea_wind_daemon/`](homeassistant/nmea_wind_daemon/) |
| **ESPHome Device Builder** add-on | ESPHome dashboard on the boat (builds from the pushed `/config/esphome`) | [`homeassistant/esphome/`](homeassistant/esphome/) |
| **Advanced SSH** add-on | Deploy/ops access for the Mac scripts | `scripts/ha-ssh.sh` |
| MQTT republish | HA → `sisu/v1` topics for Signal K | [`automations.yaml`](homeassistant/automations.yaml) |
| Victron GX bridge | Battery SoC/V/I, solar, loads from the Color Control's own MQTT | [`packages/victron_gx.yaml`](homeassistant/packages/victron_gx.yaml), [`python_scripts/victron_gx.py`](homeassistant/python_scripts/victron_gx.py) |
| Spectra bridge | Watermaker state/control over the Spectra WebSocket | [`packages/spectra_newport.yaml`](homeassistant/packages/spectra_newport.yaml), [`python_scripts/spectra_ws.py`](homeassistant/python_scripts/spectra_ws.py) |
| Internet sources | Open-Meteo weather, NOAA tides | [`python_scripts/`](homeassistant/python_scripts/) |
| Cameras | SV3C forward / aft on the LAN (`192.168.0.33` / `.34`) — snapshots, dinghy watch | [`packages/sv3c_*_camera.yaml`](homeassistant/packages/) |
| Source health, anchor watch, polar logging, trending | Liveness per source; anchor alarm; wind/speed logging; history → Influx on the F8 | [`packages/`](homeassistant/packages/) |

### TerraMaster F8 — Docker stack, `192.168.0.21`

All services use host networking; defined in [`homeassistant/docker-compose.yml`](homeassistant/docker-compose.yml).

| Service | Port | Does |
|---|---|---|
| **signalk-server** | `3000` | Signal K; subscribes to the Green MQTT kernel; KIP / Freeboard apps built in |
| **influxdb** (v2) | `8086` | Long-term history (bucket `Sisu`), written by HA |
| **grafana** | `3001` | Graphs from Influx ([`grafana-provisioning/`](homeassistant/grafana-provisioning/)) |
| **sisu-nav-api** | `8088`, `8443` | Sisu Nav chart / AIS / weather / routing ([`sisu-nav/`](sisu-nav/)). `:8443` is the HTTPS page Follow me needs |
| **tileserver-gl** | `8087` | Local chart tiles for Sisu Nav |
| **mqtt-explorer** | `4000` | Browse the MQTT kernel (points at Green `:1883`) |

### Marine Boards — ESP32-S3, Sisu-IoT (ESPHome)

Shared base: [`packages/marine_board_base.yaml`](homeassistant/esphome/packages/marine_board_base.yaml) (Wi‑Fi, API, INA226 bus, buzzer, RGB status LED).

Board revisions: the **v1.00 prototype** was retired after a U3 failure (KiCad files in [`MarineBoard/v1.00/`](MarineBoard/v1.00/), errata in [MarineBoard/Technical Specs.md](MarineBoard/Technical%20Specs.md)); the five production boards are **v1.9** ([release identity](MarineBoard/v1.9/README.md)), not yet aboard. The current KiCad design is **v1.10** and has **no board in production yet**. The root [`MarineBoard/production/`](MarineBoard/production/) package remains the v1.9 order package.

| Board | IP | Firmware | Runs locally |
|---|---|---|---|
| Alternator Port | `.41` | [`alternatorport.yaml`](homeassistant/esphome/alternatorport.yaml) | Field PWM PID, Victron-style stages, **hard cut-offs** 250 A / 14.4 V / 125 °C, fault latch, shadow mode ([`marine_alternator.yaml`](homeassistant/esphome/packages/marine_alternator.yaml)) |
| Alternator Starboard | `.42` | [`alternatorstarboard.yaml`](homeassistant/esphome/alternatorstarboard.yaml) | Same; the two share a house-current budget (300 A combined, #16/#62) |
| Water Levels | `.43` | [`waterlevels.yaml`](homeassistant/esphome/waterlevels.yaml) | Two 4–20 mA tank senders, house voltage at the saloon |
| Freezer | `.44` | [`freezer_marineboard.yaml`](homeassistant/esphome/freezer_marineboard.yaml) | Thermostat and compressor relay, full speed or stop, on a v1.9 board once fitted (freezer manual until then). Its screen is the LilyGo S3 AMOLED at `.47` ([`freezer_display.yaml`](homeassistant/esphome/freezer_display.yaml)), over ESP-NOW. Weekender wiring: [`Freezer-Replacement-Plan.md`](MarineBoard/Documentation/Freezer-Replacement-Plan.md) |

### Other devices

| Device | Where | Role |
|---|---|---|
| Saloon display (Waveshare 4.3B ESP32-S3) | Sisu-IoT `.45` | Guest touch display ([`saloon_display.yaml`](homeassistant/esphome/saloon_display.yaml)) |
| Anchor tension (LilyGo, planned) | Sisu-IoT `.46` | Load cell ([`anchortension.yaml`](homeassistant/esphome/anchortension.yaml), #34) |
| Yacht Devices YDWG-02 | Sisu-IoT `.30` | N2K → NMEA 0183 TCP (primary instrument source) |
| PredictWind DataHub | Sisu-IoT `.31` | N2K → NMEA 0183 TCP (fail-over) |
| Victron Color Control GX | Sisu-IoT `.32` | Batteries, solar, inverter over local MQTT |
| Spectra Newport 400c | LAN `.25` | Watermaker controller (WebSocket) |
| N2K backbone | — | Raymarine instruments, engines; Veratron OL43 helm display planned |

Data flow and naming in detail: [`.ai_context/data_flow.md`](.ai_context/data_flow.md), [`NETWORK.md`](NETWORK.md) §7, [`OPS.md`](OPS.md) §7. `docker-compose.mac.yml` is rollback only.

## Features (short)

- Alternator PID, Victron-style float/absorption, hard house voltage ceiling **14.4 V**
- House voltage at **each Marine Board** (wiring drop / corrosion compare)
- Fresh water levels (4–20 mA)
- Freezer split (pending a v1.9 board): Marine Board controls (`freezer_marineboard.yaml`), LilyGo AMOLED displays (`freezer_display.yaml`)
- MQTT → Signal K; long-term graphs via **Grafana + InfluxDB** on F8

## Secrets

**One** `homeassistant/secrets.yaml` for the boat (gitignored, never committed):

- `wifi_ssid` / `wifi_password` → **Sisu-IoT** only (ESPs)
- `mqtt_broker` → **HA Green `192.168.0.20`** (kernel); F8 `.21` is SK / Grafana / Influx / Sisu Nav
- HA Green needs no Wi‑Fi secrets

**[`homeassistant/secrets.yaml.example`](homeassistant/secrets.yaml.example)** is the committed template — copy it to `secrets.yaml` and fill in real values. Every key has a comment explaining what it is and exactly where to get or generate it (router UI, HA's own onboarding wizard, a keygen one-liner, a device's first-run setup screen, etc.), so implementing this on your own boat doesn't require reverse-engineering anything. Kept in sync automatically — `./scripts/scan_secrets.sh` fails the commit if the two files' keys ever drift apart.

See `NETWORK.md` §6 / `.ai_context/secrets.md` for the full policy.

## Install (high level)

0. After cloning: `git config core.hooksPath .githooks` (secret guards on commit/push — `scan_secrets.sh` insists on it once `secrets.yaml` exists).
1. Wire **HA Green** and **F8** to router Ethernet; configure SSIDs/routing per `NETWORK.md`.
2. Complete **human one-time steps** in **`OPS.md` §4** (SSH protection mode, ESPHome app, router rules).
3. Agent deploys config from the Mac (source of truth): `./scripts/ha-deploy-config.sh <files>` + `./scripts/stack-drift.sh`.
4. Marine Board GPIO mapping (lab, not a vessel role): **`bench_marine_board.yaml`**. First vessel flash is **shadow** (`INSTALLATION.md` §6.4).
5. F8 Docker (`homeassistant/docker-compose.yml` via `./scripts/f8-deploy.sh`): Signal K, InfluxDB, Grafana, **Sisu Nav** at `http://192.168.0.21:8088`. MQTT kernel stays on Green.
6. Flash production ESPs on Sisu-IoT (`alternator*`, `waterlevels`, `freezer_marineboard`, `freezer_display`, `saloon_display`).
7. From a client on **Sisu**, open HA and confirm entities online.
8. Future Helm MFD: Veratron OL 43 Smart Marine Monitoring TFT MFD Display NMEA 2000 N2K Touchscreen

## Safety

Controls live marine electrics. Bench-test before engine-room OTA. Helm gauges must remain trustworthy on **N2K** even if Wi‑Fi fails.

## License

[Apache License 2.0](LICENSE) — covers the original work in this repository (configuration, firmware YAML, scripts, Sisu Nav, documentation, and the Marine Board design files authored for this project).

Third-party material vendored here keeps its **own** license and is not relicensed: Espressif KiCad libraries (`MarineBoard/Lib/*/com_github_espressif_kicad-libraries/`), the impartGUI KiCad plugin (`MarineBoard/Lib/plugins/com_github_Steffen-W_impartGUI/`), JLCPCB library metadata (`MarineBoard/Lib/JLCPCB_*`), and EasyEDA/LCSC-derived footprints, symbols and 3D models (`MarineBoard/Lib/EasyEDA.*`, `MarineBoard/Lib/Models/`). npm dependencies are under their own licenses.

## KiCad design MarineBoard/MarineBoard.kicad_pcb

File MarineBoard/README.md:

# Sisu Marine Board

A robust, battery-powered ESP32-S3 board designed for real-world 12 V applications — featuring CAN bus, high-current PWM, relay output, power monitoring, and protected I/O.

Perfect for motor control, sensor hubs, marine/RV systems, automotive projects, and industrial IoT.

## ✨ Features

- **ESP32-S3-WROOM-2** module with Wi-Fi + Bluetooth 5
- 12 V battery input with robust power filtering and protection
- **CAN bus** interface (ISO 11898-1 compliant)
- **High-current PWM** driver with MOSFET output
- **12 V SPDT Relay** with opto-isolation
- **3× INA226** precision voltage & current monitors (I²C)
- Opto-isolated and ESD-protected digital/sensor inputs
- USB-C for easy programming and serial console
- Reset & Boot buttons, RGB status LED (WS2812B-2020 on GPIO1, v1.9) + power LED, and magnetic buzzer (GPIO2 — use firmware helpers, not a static pin)
- Clearly labeled headers for quick wiring

## 📋 Technical Specifications

**Revisions:** the KiCad project here is the current design, **v1.10**, with **no board in production yet**. The five boards ordered from PCBWay (`W831004AS1P18`) are **v1.9**, as silkscreened; that design and its fab package are archived in [`v1.9/`](v1.9/), with the frozen release identity in [`v1.9/README.md`](v1.9/README.md). The root `production/` package remains the v1.9 order package — do not rebuild it for v1.10 until the design differences land. The first build, **v1.00**, was the prototype; it was retired on 2026-10-20 after U3 failed. Its files are in [`v1.00/`](v1.00/) and its errata in [Technical Specs.md](Technical%20Specs.md#v100-prototype-retired).

### Version routing

| Question | Read |
|---|---|
| “What is the current design?” | [Technical Specs.md](Technical%20Specs.md) — **v1.10 source**, no board |
| “What board do I have / install / test?” | [`v1.9/README.md`](v1.9/README.md) for identity; [`temp-fix-v1.9.md`](temp-fix-v1.9.md) for v1.9 actions and accepted risks |
| “What changes are planned for the next board?” | [Technical Specs.md § Next spin](Technical%20Specs.md#next-spin--decided-changes-not-fitted-on-v19) — **not fitted on v1.9** |

A v1.9 answer must separate **fitted v1.9 hardware + its mitigations** from **future next-spin corrections**. Do not answer a v1.9 install question from the current v1.10 design alone.

### Main board and daughter boards

The main-board spec is the baseline and the interface contract (power, CAN/I²C, field, relay, connectors). Optional functions live in their own daughter folder and spec, e.g. [`daughter-fridge/technical spec.md`](daughter-fridge/technical%20spec.md). If a daughter function moves onto the main board, that is a new **main-board revision** with a fitted-option row — not a second main spec or a copied daughter spec.

Key highlights:

- Dual-core Xtensa LX7 @ up to 240 MHz
- Up to 32 MB Flash + 16 MB PSRAM
- Operating voltage: 9–15 V (12 V nominal)
- Free GPIO breakout headers: JP13 (GPIO13), JP16 (GPIO16), JP18 (GPIO18), JP39 (GPIO39), JP42 (GPIO42)
- Extensive ESD, TVS, and opto-isolation protection

## 📁 Repository Contents

- `hardware/` – Schematics, PCB layout, and Gerber files
- `enclosure/` – Printed PA12 enclosure: FreeCAD script, STEP/STL, board fit check (see *Enclosure* in [Technical Specs.md](Technical%20Specs.md))
- `firmware/` – Example code (Arduino / ESP-IDF)
- `docs/` – Additional documentation
- `images/` – High-resolution board photos and diagrams
- `technical-spec.md` – Detailed technical specification
- `pinout.png` – Visual GPIO and connector reference

## 🚀 Quick Start

1. **Clone the repository**

   ```bash
   git clone https://github.com/yourusername/esp32-s3-control-board.git
   cd esp32-s3-control-board

   ```

2. **Power the board**
   Connect a 12 V battery to the +12V BAT header, or
   Plug in USB-C (for programming and 3.3 V power)

3. **Flash firmware**
   Hold Boot button → Press and release Reset button
   Use ESP-IDF, Arduino IDE, or ESPTool to flash

4. **Explore examples**
   Basic blink + Wi-Fi
   CAN bus communication
   PWM motor control
   Relay switching
   Battery & voltage monitoring via INA226

5. **📊 Pinout & Connectors**
   
   Main Connectors:

Power: +12 V BAT, PWM, GND
Sensors: SH± (current shunt), LVL1, LVL2
I²C: S_GPIO± (SDA/SCL for INA226 monitors)
CAN: CANH, CANL, GND
Control: ENBL, RPM, TMP1
Relay: NO1, NC1, CO1

Full pin mapping and GPIO usage available in Technical Specs.md. 5. **🛠️ Hardware Protection**

ESD protection on all external I/O
Optocouplers on RPM, Enable, and Relay signals
TVS diodes and common-mode chokes on CAN
Fuse and reverse-polarity protection on 12 V input
Ferrite beads and extensive decoupling

6. **📄 Documentation**

Technical Specs.md – Complete technical reference
[kicad-skills/README.md](kicad-skills/README.md). Find a part, draw a KiCad 10 symbol, place footprints, and check the sheet and the board. Library nicknames are in [Technical Specs.md](Technical%20Specs.md#schematic-symbols).
Getting Started (coming soon)
Schematic section pictures in `Documentation/Schematics/`

7. **🧩 Supported Frameworks**

ESP-IDF (recommended for maximum performance)
Arduino-ESP32
MicroPython / CircuitPython
PlatformIO

8. **📬 Contributing**
   Contributions, issues, and feature requests are welcome!
   Feel free to open an issue or submit a pull request.

9. **📜 License**
   This project is licensed under the MIT License — see the LICENSE file for details.

10. **❤️ Acknowledgments**

Espressif Systems for the excellent ESP32-S3-WROOM-2 module
Open-source hardware and firmware community

Made for makers who need reliability in the real world.
Questions? Open an issue or reach out on X @SailingSisu.
Happy hacking! ⚡

Parts:
BUZZER1: KLJ-4020; BUZ-SMD_L4.0-W4.0-P3.50-L; MPN KLJ-4020
C1, C25: 10uF; C_0402_1005Metric; MPN CL05A106MQ5NUNC
C2, C3, C5, C7, C9, C24, C27, C28, C31, C32, C34, C35, C36, C37, C38, C40: 0.1uF; C_0402_1005Metric; MPN CL05B104KO5NNNC
C4, C8: 22uF; C_0402_1005Metric; MPN GRM158R61A226ME15D
C6: 6.8pF; C_0402_1005Metric; MPN GJM1555C1H6R8BB01D
C11, C12, C19, C42: 0.1uF; C_0402_1005Metric; MPN CL05B104KB5NNNC
C13: 10uF/50V; C_0805_2012Metric; MPN GRM21BR61H106KE43L
C14: 0.1uF; C_0402_1005Metric; MPN CL05B104KB5NNNC; JLCPCB ID C960916
C15: 47uF; C_1206_3216Metric; MPN GRM31CR61E476ME44L
C16: 4.7uF; C_1206_3216Metric; MPN CL31B475KBHNNNE
C17: 10uF; C_1206_3216Metric; MPN CL31A106KBHNNNE
C18: 10nF; C_0402_1005Metric; MPN CL05B103KB5NNNC
C20: 220uF 10V; CAP-SMD_BD6.3-L6.6-W6.6-FD; MPN 10SVPE220M
C26, C29: 47nF; C_0402_1005Metric; MPN GCM155R71H473KE02D
C30: 4.7uF; C_0402_1005Metric; MPN CL05A475MP5NRNC
C33: 1uF; C_0402_1005Metric; MPN GRM155R61H105KE05D; JLCPCB ID C1518208
C39: 1.2uF 100V; C_1210_3225Metric; MPN FS32X125K101EGG
CN1, CN2: MKDSN 1,5/ 2-5,08; CONN-TH_2P-P5.08_1729128; MPN 1729128
CN3: SM04B-SRSS-TB (LF)(SN); CONN-SMD_4P-P1.00_SM04B-SRSS-TB-LF-SN; MPN SM04B-SRSS-TB(LF)(SN)
CN4: BM10B-GHS-TBT; CONN-SMD_BM10B-GHS-TBT-LF-SN; MPN BM10B-GHS-TBT(LF)(SN); LCSC Part C495732
D1, D4, D15, D17: SS14; D_SMA; MPN SS14
D2, D3: H5VL10B; D_SOD-882; CLAMPING VOLTAGE 10V; VOLTAGE - BREAKDOWN 5.6V; MPN H5VL10B; JLCPCB PART CLASS Extended Part
D5: WS2812B-2020-V6; LED_WS2812B-2020_PLCC4_2.0x2.0mm; MPN WS2812B-2020-V6
D6: SMBJ18A; D_SMB; MPN SMBJ18A
D7: LMBR340FT1G; D_SOD-123F; MPN LMBR340FT1G
D8: VS-43CTQ100S-M3; D2PAK_L10.0-W9.0-P2.54-LS15.0-TL-1; MPN VS-43CTQ100S-M3
D9, D11, D12, D13, D18, D19: ESD5Z3.3T1G; D_SOD-523; MPN ESD5Z3.3T1G
D10: PESD1CAN; SOT-23; MPN PESD1CAN
D14: SS56; D_SMA; MPN SS56
D16: KT-0603R; LED_0603_1608Metric; MPN KT-0603R
D20: MBRS3100T3G; D_SMC; MPN MBRS3100T3G
D21: 1N4148W; D_SOD-123; MPN 1N4148W-7-F
D22: S3MB-13-F; D_SMB; MPN S3MB-13-F
F1: 2A; FUSE-TH_XF-506P; MPN XF-506P
F2: 1A; FUSE-TH_XF-506P; MPN XF-506P
F3, F4: 10A; FUSE-TH_XF-506P; MPN XF-506P
Flash1: Flash; SW_Push_1P1T_XKB_TS-1187A; MPN TS-1187A-B-A-B
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3; not fitted
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A; MPN HC-TYPE-C-16P-01A
JP1: CAN Bus Term; PinHeader_1x02_P1.27mm_Vertical; MPN 1.27-1*2PPin
L1: 1uH 3.3A 40mΩ; L_1008_2520Metric; MPN DFE252012F-1R0M=P2
L2: 22uH; IND-SMD_L12.5-W12.5_B82477P4XX; MPN FC-DR1207-220MT
L3, L4, L6: BLM21PG121SN1D; L_0805_2012Metric; TOLERANCE ±25%; CURRENT RATING 3A; MPN BLM21PG121SN1D; JLCPCB PART CLASS Extended Part
L5: CDRH104RNP-150NC; IND-SMD_L10.2-W10.0; MPN CDRH104RNP-150NC
L7, L9, L10: BLM21PG331SN1D; L_0805_2012Metric; MPN BLM21PG331SN1D
L8: DLW21SN900SQ2L; FILTER-SMD_4P-L2.0-W1.2-BL_DLW21H; MPN DLW21SN900SQ2L
Q2, Q3: S8050; SOT-23; MPN S8050; JLCPCB PART CLASS 扩展库
Q4: BUK762R4-60E; TO-263-2_L10.1-W9.1-P5.08-LS15.2-BR; MPN BUK762R4-60E,118-VB
R1, R2: 5.1K; R_0402_1005Metric; MPN 0402WGF5101TCE
R3, R10, R15, R20, R25, R26, R27, R28, R32, R40, R42, R43: 10K; R_0402_1005Metric; MPN 0402WGF1002TCE
R4: 100K; R_0805_2012Metric; MPN 0805W8F1003T5E
R5, R6: 33R; R_0402_1005Metric; MPN 0402WGF330JTCE
R7, R9, R35, R36: 10; R_0805_2012Metric; MPN FRC0805J100 TS
R8: 22K; R_0805_2012Metric; MPN 0805W8F2202T5E
R11: 200m; R_0201_0603Metric; MPN PE0201FRF7W0R2L
R12: 3k24; R_0402_1005Metric; MPN 0402WGF3241TCE
R14, R19, R21, R23, R24, R49, R50: 120; R_0805_2012Metric; MPN 0805W8F1200T5E
R16: 10K/1W; R_2512_6332Metric; MPN 25121WJ0103T4E
R22, R29, R30, R41, R44: 1K; R_0402_1005Metric; MPN 0402WGF1001TCE
R31: 100; R_0805_2012Metric; MPN 0805W8F1000T5E
R33: 470R; R_0402_1005Metric; MPN 0402WGF4700TCE
R34: 100; R0402; MPN 0402WGF1000TCE; LCSC Part C25076
R38, R39: 3.9; R_0805_2012Metric; MPN CL0805FN3R9PS
R46: 47K/1W; R_2512_6332Metric; MPN CR2512F47K0E04Z
R47: 2K2; R_2512_6332Metric; MPN CRGP2512F2K2
R48: 47K; R_0402_1005Metric; MPN 0402WGF4702TCE
Relay1: SRD-12VDC-SL-C; RELAY-TH_SRD-XXVDC-XL-C; MPN SRD-12VDC-SL-C
Reset1: Reset; SW_Push_1P1T_XKB_TS-1187A; MPN TS-1187A-B-A-B
TP1: GND; TestPoint_Pad_D1.5mm
TP2: +12V; TestPoint_Pad_D1.5mm
TP3: +5V_VCC; TestPoint_Pad_D1.5mm
TP4: +3.3V; TestPoint_Pad_D1.5mm
TP5: PWM_GATE; TestPoint_Pad_D1.5mm
TP6: VSENSE; TestPoint_Pad_D1.5mm
U1: SY8089A1AAC; TSOT-23-5; MPN SY8089A1AAC
U2, U18, U19: INA226; VSSOP-10_3x3mm_P0.5mm; MPN INA226AQDGSRQ1
U3: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias; MPN TPS5430DDA
U4, U5, U6: DB125-3.5-2P-GN-S; CONN-TH_2P-P3.50_L7.4-W7.0; MPN DB125-3.5-2P-GN-S
U7, U9, U12, U13: DB125-3.5-3P-GN-S; CONN-TH_3P-P3.50_L7.4-W10.5; MPN DB125-3.5-3P-GN-S
U8: ESP32-S3-WROOM-2-N32R16V; ESP32-S3-WROOM-2; MPN ESP32-S3-WROOM-2-N32R16V
U11: SN65HVD230DR; SOIC-8_3.9x4.9mm_P1.27mm; MPN SN65HVD230DR
U14, U16, U17, U21: PC817C-S; SOP-4_L6.5-W4.6-P2.54-LS10.3-TL; MPN PC817C-S
U22: SN74LVC1G14DBVR; SOT-23-5; MPN SN74LVC1G14DBVR
U23: MCP1407-E/MF; DFN-8_L6.0-W5.0-P1.27-BL-EP4.0; MPN MCP1407-E/MF

Connections:
5V_BUCK: C20.1, L5.2, L6.1, R10.2
5V_FILT: F2.1, L6.2
5V_FUSED: D4.2 (A), F2.2
+3.3V: BUZZER1.1 (+), C2.2, C3.1, C4.2, C6.2, C28.2, C30.2, CN3.2, CN4.1, D16.2 (A), D17.1 (K), L1.2, L7.2, L9.1, L10.1, R4.2, R15.2, R20.2, R25.2, R27.1, R28.1, TP4.1 (1_1), U2.6 (VS), U9.1, U11.3 (VCC), U14.4, U18.2 (A0), U19.1 (A1), U19.2 (A0), U21.4, U22.5 (VCC)
+5V_VCC: C5.1, C8.2, CN4.10, D1.1 (K), D4.1 (K), D21.2 (A), R3.1, TP3.1 (1_1), U1.4 (IN), U9.2
+12V: C13.1, C14.1, C33.2, D15.1 (K), L4.2, Relay1.1, TP2.1 (1_1), U5.1, U6.2, U17.4, U18.8 (Vbus), U19.8 (Vbus), U23.1 (VDD), U23.8 (VDD)
+12V BAT: C42.1, CN1.2, CN2.1, D8.2 (-), D14.2 (A), U16.4
BL/GPIO18: CN4.9, U8.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
BOOT: C35.2, Flash1.2, R28.2, U8.27 (GPIO0/BOOT)
BUZZ: R44.2, U8.38 (GPIO2/TOUCH2/ADC1_CH1)
CAN RX_GPIO: U8.6 (GPIO6/TOUCH6/ADC1_CH5), U11.4 (RXD)
CAN TX_GPIO: U8.5 (GPIO5/TOUCH5/ADC1_CH4), U11.1 (TXD)
CANH: D10.2, L8.1, U7.1
CANL: D10.1, L8.4, U7.2
CO1: F4.1, U12.2
CS0/GPIO10: CN4.6, U8.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
DC/GPIO9: CN4.7, U8.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
ENBL: R22.1, U13.1
ENBL_GPIO: R23.2, U8.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
ESP_3V3: C24.2, C25.1, L7.1, U8.2 (3V3)
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C7.2, C8.1, C11.1, C12.2, C13.2, C14.2, C16.1, C17.2, C19.2, C20.2, C24.1, C25.2, C26.2, C27.1, C28.1, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.2, C37.1, C38.1, C40.1, C42.2, CN1.1, CN3.1, CN3.5, CN3.6, CN4.2, CN4.11, CN4.12, D2.2 (A), D3.1 (C), D5.2 (VSS), D6.2 (A), D7.2 (A), D9.1 (A), D10.3, D11.1 (A), D12.1 (A), D13.1 (A), D18.1 (A), D19.1 (A), D20.2 (A), D22.2, Flash1.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), Q2.2 (E), Q3.2 (E), Q4.3 (S), R1.1, R2.1, R8.1, R11.1, R12.1, R26.2, R32.2, R33.2, R38.1, R39.1, R40.2, R42.1, R43.2, R46.1, R48.2, Reset1.1, TP1.1 (1_1), U1.2 (GND), U2.1 (A1), U2.2 (A0), U2.7 (GND), U3.6 (GND), U3.9 (GNDPAD), U7.3, U8.1 (GND), U8.40 (GND), U8.41 (GND), U9.3, U11.2 (GND), U11.8 (S), U14.2, U16.2, U17.2, U18.1 (A1), U18.7 (GND), U18.9 (Vin-), U19.7 (GND), U19.9 (Vin-), U21.2, U22.3 (GND), U23.4 (GND), U23.5 (GND), U23.9 (EP)
LED: R34.2, U8.39 (GPIO1/TOUCH1/ADC1_CH0)
LVL1: R35.1, U5.2
LVL2: R36.1, U6.1
MISO/GPIO13: CN4.5, U8.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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)
MOSI/GPIO11: CN4.4, U8.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
NC1: Relay1.3, U12.1
NO1: Relay1.2, U12.3
unnamed: BUZZER1.2 (-), D17.2 (A), Q3.3 (C)
unnamed: C15.2, R11.2
unnamed: C36.1, R31.1
unnamed: C39.2, R16.2
unnamed: D2.1 (C), J1.A7 (D-), J1.B7 (D-), R5.1
unnamed: D3.2 (A), J1.A6 (D+), J1.B6 (D+), R6.1
unnamed: D5.3 (DIN), R34.1
unnamed: D12.2 (K), R22.2, U14.1
unnamed: D15.2 (A), Q2.3 (C), Relay1.4
unnamed: D16.1 (K), R33.1
unnamed: C38.2, D18.2 (K), R35.2, R38.2, U18.10 (Vin+)
unnamed: C37.2, D19.2 (K), R36.2, R39.2, U19.10 (Vin+)
unnamed: D20.1 (C), R16.1, R46.2, R47.1
unnamed: C40.2, D5.4 (VDD), D21.1 (K)
unnamed: D22.1, R47.2, U21.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: JP1.2, R21.1
unnamed: Q2.1 (B), R41.1, R42.2
unnamed: Q3.1 (B), R43.1, R44.1
unnamed: R23.1, R26.1, U14.3
unnamed: R29.2, U16.1
unnamed: R30.2, U17.1
unnamed: R32.1, R50.2, U16.3
unnamed: R41.2, U17.3
unnamed: R3.2, U1.1 (EN)
unnamed: C6.1, R4.1, R8.2, U1.5 (FB)
unnamed: C9.2, C12.1, R7.2, U2.8 (Vbus), U2.10 (Vin+)
unnamed: C9.1, C11.2, R9.1, U2.9 (Vin-)
unnamed: C18.2, U3.1 (BOOT)
unnamed: C26.1, L8.2, R21.2, U11.7 (CANH)
unnamed: C29.1, JP1.1, L8.3, U11.6 (CANL)
unnamed: C27.2, U11.5 (VREF)
unnamed: C31.2, L9.2, U18.6 (VS)
unnamed: C32.2, L10.2, U19.6 (VS)
unnamed: R48.1, U21.3, U22.2 (A)
unnamed: R49.1, U22.4 (Y)
unnamed: R50.1, U23.2 (INPUT)
PWM: CN2.2, F3.1
PWM1_GPIO: R29.1, U8.31 (GPIO38/FSPIWP/SUBSPIWP)
PWM_DRIVE: D8.1 (+), D8.3 (+), F3.2, Q4.2 (D), R31.2
PWM_GATE: Q4.1 (G), R40.1, TP5.1 (1_1), U23.6 (OUT), U23.7 (OUT)
RESET: C34.2, R27.2, Reset1.2, U8.3 (EN)
RLY1_COM: F4.2, Relay1.5
RLY1_GPIO: R30.1, U8.7 (GPIO7/TOUCH7/ADC1_CH6)
RPM: C39.1, U13.2
RPM_GPIO: R49.2, U8.4 (GPIO4/TOUCH4/ADC1_CH3)
RST/GPIO14: CN4.8, U8.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
SCK/GPIO12: CN4.3, U8.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
SCL: CN3.4, D11.2 (K), R19.1, R20.1
SDA: CN3.3, D13.2 (K), R24.1, R25.1
SH+: R7.1, U4.2
SH-: R9.2, U4.1
SW_3V3: L1.1, U1.3 (LX)
SW_5V: C18.1, D7.1 (C), L5.1, U3.8 (PH)
S_GPIO+: R24.2, U2.4 (SDA), U8.33 (MTDO/GPIO40/CLK_OUT2), U18.4 (SDA), U19.4 (SDA)
S_GPIO-: R19.2, U2.5 (SCL), U8.34 (MTDI/GPIO41/CLK_OUT1), U18.5 (SCL), U19.5 (SCL)
TMP1: D9.2 (K), R14.1, R15.1, U13.3
TMP1_GPIO: R14.2, U8.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
USB_D+: R6.2, U8.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
USB_D-: R5.2, U8.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
VBUS: C1.1, C7.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
VIN_BUCK: C16.2, C17.1, L3.2, L4.1, U3.7 (VIN)
VIN_FILT: C15.1, L2.2, L3.1
VIN_FUSED: C19.1, D6.1 (C), F1.2, L2.1
VIN_RP: D14.1 (K), F1.1
VSENSE: R10.1, R12.2, TP6.1 (1_1), U3.4 (VSENSE)

Notes on the sheet:
输出继电器
1.0
TEST POINTS
IO PROTECTION
LEDS & BUTTONS & BUZZER
ESP32
脉宽调制驱动器
HEADER PINS
OUTPUT RELAY
ADDR: 0x45
ADDR: 0x40
I²C
USB-C Program
12V电池监控器
LEVELS MONITOR
CAN INTERFACE
PWM DRIVER
RPM input
SW-LT100 12V, 4-20mA
DS18B20 1-Wire
水平检测器
CAN 接口
ADDR: 0x41
LED/按钮/蜂鸣器
NEW
POWER AND FILTERING
12V BATTERY MONITOR
CAN / SeaTalkNG
23 October 2026
Sisu Marine Board v1.10
+12V Battery

Notices in the files:
MarineBoard/README.md:
License: MIT
